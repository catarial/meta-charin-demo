KERNEL_IMAGETYPE = "Image"
